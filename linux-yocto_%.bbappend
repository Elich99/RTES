FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://hello.patch"